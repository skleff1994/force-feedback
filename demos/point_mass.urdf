Commit message: started 2dof manip and added lpf

File: demos/point_mass.urdf (robot description, URDF)
Before this commit: robot PointMass, 1 links, 0 joints
Links:
- link contact: geometry collision mesh filename=package://config/sphere.obj; visual mesh filename=package://config/sphere.obj
